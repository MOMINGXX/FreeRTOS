# Keil uVision project STM32F103_FreeRtos.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103_FreeRtos
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\HardWare;.\Library\inc;.\Library\src;.\Start;.\System;.\User;.\FreeRtos;.\FreeRtos\Include;.\FreeRtos\Portable;.\FreeRtos\Source
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: startup_stm32f10x_hd.s
  group HardWare
    ./HardWare/: USART.c
  group Libraary
    ./Library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c misc.c
  group System
    ./System/: system_stm32f10x.c
  group FreeRtos
    ./FreeRtos/Portable/: heap_4.c port.c
    ./FreeRtos/Source/: tasks.c queue.c croutine.c event_groups.c list.c stream_buffer.c timers.c
    ./FreeRtos/: FreeRTOSConfig.h
  group User
    ./User/: main.c stm32f10x_it.c stm32f10x_conf.h
