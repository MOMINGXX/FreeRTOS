# Keil uVision project Project.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F446xx,USE_STDPERIPH_DRIVER
  c include: D:\Keil_v5\ARM\Packs\ARM\CMSIS\6.1.0\CMSIS\Core\Include;.\HardWare;.\Library\inc;.\Library\src;.\Start;.\System;.\User;.\FreeRtos;.\FreeRtos\Include;.\FreeRtos\Portable;.\FreeRtos\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Start
    ./Start/: startup_stm32f446xx.s system_stm32f4xx.c
  group Library
    ./Library/src/: stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c misc.c
  group HardWare
    ./HardWare/: KEY.c LED.c MPU6050.c NRF24L01.c ROUKER.c LCD.c LCD_Init.c W25Q128JV.c LCD_MENU.c
  group System
    ./System/: LCD_SPI.c MPU6050_I2C.c NRF24L01_SPI.c USART.c TIMERx.c W25Q128JV_SPI.c Delay.c
  group FreeRttos
    ./FreeRtos/: FreeRTOSConfig.h
    ./FreeRtos/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRtos/Portable/: heap_4.c port.c portmacro.h
  group User
    ./User/: main.c stm32f4xx_it.c stm32f4xx_conf.h
